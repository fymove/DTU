# Keil uVision project DTU-200.uvprojx, settings and files
target DTU-200_Realse (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: X-DTU +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin -o ../Bin/@L.bin ./Obj/@L.axf
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,PRJ_RELEASE
  c misc: --C99
  c include: ..\STM32F10x_StdPeriph_Driver;..\STM32F10x_StdPeriph_Driver\inc;..\RTE;..\RTE\CoreSupport;..\RTE\Device;..\App;..\App\DevLayer;..\App\AppLayer;..\App\sfud\inc;..\App\crc
  memory RVCT4: ROM 0x8001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/: main.c
    ../App/AppLayer/: bsp.c App_AlarmEvent.c App_Debug.c App_json.c App_led.c App_Para.c App_plt.c App_UsrCmd.c App_vfd.c comm.c Simulation.c App_DtuCfg.c App_rtc.c App_MultFun.c App_Upgrade.c
    ../STM32F10x_StdPeriph_Driver/: stm32f10x_it.c
  group Device
    ../App/DevLayer/: GC65.c GC65_Bsp.c SST25VF_Bsp.c SST25VF_flash.c uart.c pipe.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_can.c
  group Lib
    ../App/AppLayer/: App_Protocol.c
  group Sfud
    ../App/sfud/src/: sfud.c sfud_sfdp.c
    ../App/sfud/port/: sfud_port.c
  group Crc
    ../App/crc/: crc32.c
target DTU-200_Debug (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: DTU200 +hex
  AfterMake: as above
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --C99
  c include: ..\STM32F10x_StdPeriph_Driver\inc;..\App\DevLayer;..\App\AppLayer;..\App;..\RTE\CoreSupport;..\RTE\Device;..\STM32F10x_StdPeriph_Driver;..\App\sfud\inc;..\App\crc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
target DTU-200 103RC (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: DTU-103RC +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin -o ../Bin/DTU-103RC.bin ./Objects/DTU-103RC.axf
  c flags: Optim=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,F103RCT6,PRJ_RELEASE
  c include: ..\STM32F10x_StdPeriph_Driver;..\STM32F10x_StdPeriph_Driver\inc;..\RTE;..\RTE\CoreSupport;..\RTE\Device;..\App;..\App\DevLayer;..\App\AppLayer
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
